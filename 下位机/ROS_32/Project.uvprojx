# Keil uVision project Project.uvprojx, settings and files
target ROS_32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\System;.\Hardware\enconder;.\Hardware\key;.\Hardware\led;.\Hardware\motor;.\Hardware\oled;.\Hardware\pwm;.\Hardware\IMU901;.\Hardware\USART2;.\Software;.\System\SysTick;.\Hardware\Serial
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\Objects\Project.sct
  group Start
    ./Start/: startup_stm32f10x_md.s core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group System
    ./System/: Delay.c Delay.h Timer.c Timer.h PID.c PID.h
    ./System/SysTick/: bsp_SysTick.c bsp_SysTick.h
  group Hardware
    ./Hardware/enconder/: Encoder.c Encoder.h
    ./Hardware/key/: Key.c Key.h
    ./Hardware/led/: LED.c LED.h
    ./Hardware/motor/: Motor.c Motor.h
    ./Hardware/oled/: OLED.c OLED.h OLED_Font.h
    ./Hardware/pwm/: PWM.c PWM.h
    ./Hardware/IMU901/: imu901.c imu901.h ringbuffer.c ringbuffer.h
    ./Hardware/USART2/: usart2.c usart2.h
    ./Hardware/Serial/: Serial.c Serial.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h config.h
  group Software
    ./Software/: scheduler.c scheduler.h init.c init.h
